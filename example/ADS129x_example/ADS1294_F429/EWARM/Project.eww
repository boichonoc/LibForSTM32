<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\ADS1294_F429.ewp</path>
  </project>
  <batchBuild />
</workspace>
